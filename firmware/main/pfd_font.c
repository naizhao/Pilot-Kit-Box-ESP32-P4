/*
 * pfd_font.c — PFD font implementation.
 *
 * Scale-1 and normal scaled rendering use the public-domain "font5x7"
 * table that ships with the Adafruit GFX library and dozens of embedded
 * projects before it.
 *
 * 2026-07-30：曾经还有第二条路径——12×16 的 cockpit 字形子集
 * （pfd_font_aa.c / gen_pfd_cockpit_font.py），由 pk_font_puts_cockpit()
 * 渲染。它只在 320×240 的版面里被用到，随小屏兼容预览一起删除，本文件从此
 * 只剩 5×7 位图这一条路径。留下的这份仍有用武之地：雷达距离环标数、罗盘
 * N/E/S/W 这类 1~2 个字符的极小标注，用它比抗锯齿字体更省也更锐。
 *
 * 0x7F is repurposed as the degree-symbol glyph; see PK_FONT_DEGREE.
 */

#include "pfd_font.h"

#include "pfd_draw.h"

/* Glyph table: 96 printable ASCII (0x20..0x7F) + 8 compass arrows at
 * 0x80..0x87. Each glyph is 5 columns × 7 rows, packed column-major
 * with bit 0 = top row (see PK_FONT_W / PK_FONT_H in the header).
 *
 * The arrow rows below were hand-pixel-traced; comments next to each
 * entry show the visual outcome on a 5×7 grid. */
static const uint8_t s_font[96 + 8][PK_FONT_W] = {
    {0x00,0x00,0x00,0x00,0x00}, /* 0x20  (space) */
    {0x00,0x00,0x5F,0x00,0x00}, /* 0x21 ! */
    {0x00,0x07,0x00,0x07,0x00}, /* 0x22 " */
    {0x14,0x7F,0x14,0x7F,0x14}, /* 0x23 # */
    {0x24,0x2A,0x7F,0x2A,0x12}, /* 0x24 $ */
    {0x23,0x13,0x08,0x64,0x62}, /* 0x25 % */
    {0x36,0x49,0x55,0x22,0x50}, /* 0x26 & */
    {0x00,0x05,0x03,0x00,0x00}, /* 0x27 ' */
    {0x00,0x1C,0x22,0x41,0x00}, /* 0x28 ( */
    {0x00,0x41,0x22,0x1C,0x00}, /* 0x29 ) */
    {0x14,0x08,0x3E,0x08,0x14}, /* 0x2A * */
    {0x08,0x08,0x3E,0x08,0x08}, /* 0x2B + */
    {0x00,0x50,0x30,0x00,0x00}, /* 0x2C , */
    {0x08,0x08,0x08,0x08,0x08}, /* 0x2D - */
    {0x00,0x60,0x60,0x00,0x00}, /* 0x2E . */
    {0x20,0x10,0x08,0x04,0x02}, /* 0x2F / */
    {0x3E,0x51,0x49,0x45,0x3E}, /* 0x30 0 */
    {0x00,0x42,0x7F,0x40,0x00}, /* 0x31 1 */
    {0x42,0x61,0x51,0x49,0x46}, /* 0x32 2 */
    {0x21,0x41,0x45,0x4B,0x31}, /* 0x33 3 */
    {0x18,0x14,0x12,0x7F,0x10}, /* 0x34 4 */
    {0x27,0x45,0x45,0x45,0x39}, /* 0x35 5 */
    {0x3C,0x4A,0x49,0x49,0x30}, /* 0x36 6 */
    {0x01,0x71,0x09,0x05,0x03}, /* 0x37 7 */
    {0x36,0x49,0x49,0x49,0x36}, /* 0x38 8 */
    {0x06,0x49,0x49,0x29,0x1E}, /* 0x39 9 */
    {0x00,0x36,0x36,0x00,0x00}, /* 0x3A : */
    {0x00,0x56,0x36,0x00,0x00}, /* 0x3B ; */
    {0x08,0x14,0x22,0x41,0x00}, /* 0x3C < */
    {0x14,0x14,0x14,0x14,0x14}, /* 0x3D = */
    {0x00,0x41,0x22,0x14,0x08}, /* 0x3E > */
    {0x02,0x01,0x51,0x09,0x06}, /* 0x3F ? */
    {0x32,0x49,0x79,0x41,0x3E}, /* 0x40 @ */
    {0x7E,0x11,0x11,0x11,0x7E}, /* 0x41 A */
    {0x7F,0x49,0x49,0x49,0x36}, /* 0x42 B */
    {0x3E,0x41,0x41,0x41,0x22}, /* 0x43 C */
    {0x7F,0x41,0x41,0x22,0x1C}, /* 0x44 D */
    {0x7F,0x49,0x49,0x49,0x41}, /* 0x45 E */
    {0x7F,0x09,0x09,0x01,0x01}, /* 0x46 F */
    {0x3E,0x41,0x41,0x51,0x32}, /* 0x47 G */
    {0x7F,0x08,0x08,0x08,0x7F}, /* 0x48 H */
    {0x00,0x41,0x7F,0x41,0x00}, /* 0x49 I */
    {0x20,0x40,0x41,0x3F,0x01}, /* 0x4A J */
    {0x7F,0x08,0x14,0x22,0x41}, /* 0x4B K */
    {0x7F,0x40,0x40,0x40,0x40}, /* 0x4C L */
    {0x7F,0x02,0x04,0x02,0x7F}, /* 0x4D M */
    {0x7F,0x04,0x08,0x10,0x7F}, /* 0x4E N */
    {0x3E,0x41,0x41,0x41,0x3E}, /* 0x4F O */
    {0x7F,0x09,0x09,0x09,0x06}, /* 0x50 P */
    {0x3E,0x41,0x51,0x21,0x5E}, /* 0x51 Q */
    {0x7F,0x09,0x19,0x29,0x46}, /* 0x52 R */
    {0x46,0x49,0x49,0x49,0x31}, /* 0x53 S */
    {0x01,0x01,0x7F,0x01,0x01}, /* 0x54 T */
    {0x3F,0x40,0x40,0x40,0x3F}, /* 0x55 U */
    {0x1F,0x20,0x40,0x20,0x1F}, /* 0x56 V */
    {0x7F,0x20,0x18,0x20,0x7F}, /* 0x57 W */
    {0x63,0x14,0x08,0x14,0x63}, /* 0x58 X */
    {0x03,0x04,0x78,0x04,0x03}, /* 0x59 Y */
    {0x61,0x51,0x49,0x45,0x43}, /* 0x5A Z */
    {0x00,0x00,0x7F,0x41,0x41}, /* 0x5B [ */
    {0x02,0x04,0x08,0x10,0x20}, /* 0x5C \ */
    {0x41,0x41,0x7F,0x00,0x00}, /* 0x5D ] */
    {0x04,0x02,0x01,0x02,0x04}, /* 0x5E ^ */
    {0x40,0x40,0x40,0x40,0x40}, /* 0x5F _ */
    {0x00,0x01,0x02,0x04,0x00}, /* 0x60 ` */
    {0x20,0x54,0x54,0x54,0x78}, /* 0x61 a */
    {0x7F,0x48,0x44,0x44,0x38}, /* 0x62 b */
    {0x38,0x44,0x44,0x44,0x20}, /* 0x63 c */
    {0x38,0x44,0x44,0x48,0x7F}, /* 0x64 d */
    {0x38,0x54,0x54,0x54,0x18}, /* 0x65 e */
    {0x08,0x7E,0x09,0x01,0x02}, /* 0x66 f */
    {0x08,0x14,0x54,0x54,0x3C}, /* 0x67 g */
    {0x7F,0x08,0x04,0x04,0x78}, /* 0x68 h */
    {0x00,0x44,0x7D,0x40,0x00}, /* 0x69 i */
    {0x20,0x40,0x44,0x3D,0x00}, /* 0x6A j */
    {0x00,0x7F,0x10,0x28,0x44}, /* 0x6B k */
    {0x00,0x41,0x7F,0x40,0x00}, /* 0x6C l */
    {0x7C,0x04,0x18,0x04,0x78}, /* 0x6D m */
    {0x7C,0x08,0x04,0x04,0x78}, /* 0x6E n */
    {0x38,0x44,0x44,0x44,0x38}, /* 0x6F o */
    {0x7C,0x14,0x14,0x14,0x08}, /* 0x70 p */
    {0x08,0x14,0x14,0x18,0x7C}, /* 0x71 q */
    {0x7C,0x08,0x04,0x04,0x08}, /* 0x72 r */
    {0x48,0x54,0x54,0x54,0x20}, /* 0x73 s */
    {0x04,0x3F,0x44,0x40,0x20}, /* 0x74 t */
    {0x3C,0x40,0x40,0x20,0x7C}, /* 0x75 u */
    {0x1C,0x20,0x40,0x20,0x1C}, /* 0x76 v */
    {0x3C,0x40,0x30,0x40,0x3C}, /* 0x77 w */
    {0x44,0x28,0x10,0x28,0x44}, /* 0x78 x */
    {0x0C,0x50,0x50,0x50,0x3C}, /* 0x79 y */
    {0x44,0x64,0x54,0x4C,0x44}, /* 0x7A z */
    {0x00,0x08,0x36,0x41,0x00}, /* 0x7B { */
    {0x00,0x00,0x7F,0x00,0x00}, /* 0x7C | */
    {0x00,0x41,0x36,0x08,0x00}, /* 0x7D } */
    {0x02,0x01,0x02,0x04,0x02}, /* 0x7E ~ */
    {0x06,0x09,0x09,0x06,0x00}, /* 0x7F (repurposed: degree symbol °) */

    /* 0x80 ↑ N — vertical line with wide chevron at top
     *   . . X . .
     *   . X X X .
     *   X X X X X
     *   . . X . .
     *   . . X . .
     *   . . X . .
     *   . . X . .                                                  */
    {0x04, 0x06, 0x7F, 0x06, 0x04}, /* 0x80 ↑ */

    /* 0x81 ↗ NE — diagonal SW→NE with arrowhead in upper-right corner
     *   . . X X X
     *   . . . X X
     *   . . X . X
     *   . X . . .
     *   X . . . .                                                  */
    {0x10, 0x08, 0x05, 0x03, 0x07}, /* 0x81 ↗ */

    /* 0x82 → E — horizontal line with chevron at right
     *   . . . . .
     *   . . . X .
     *   . . . X X
     *   X X X X X
     *   . . . X X
     *   . . . X .                                                  */
    {0x08, 0x08, 0x08, 0x3E, 0x1C}, /* 0x82 → */

    /* 0x83 ↘ SE — diagonal NW→SE with arrowhead in lower-right corner
     *   . . . . .
     *   . . . . .
     *   X . . . .
     *   . X . . .
     *   . . X . X
     *   . . . X X
     *   . . X X X                                                  */
    {0x04, 0x08, 0x50, 0x60, 0x70}, /* 0x83 ↘ */

    /* 0x84 ↓ S — vertical line with wide chevron at bottom
     *   . . X . .
     *   . . X . .
     *   . . X . .
     *   . . X . .
     *   X X X X X
     *   . X X X .
     *   . . X . .                                                  */
    {0x10, 0x30, 0x7F, 0x30, 0x10}, /* 0x84 ↓ */

    /* 0x85 ↙ SW — diagonal NE→SW with arrowhead in lower-left corner
     *   . . . . .
     *   . . . . .
     *   . . . . X
     *   . . . X .
     *   X . X . .
     *   X X . . .
     *   X X X . .                                                  */
    {0x70, 0x60, 0x50, 0x08, 0x04}, /* 0x85 ↙ */

    /* 0x86 ← W — horizontal line with chevron at left
     *   . . . . .
     *   . X . . .
     *   X X . . .
     *   X X X X X
     *   X X . . .
     *   . X . . .                                                  */
    {0x1C, 0x3E, 0x08, 0x08, 0x08}, /* 0x86 ← */

    /* 0x87 ↖ NW — diagonal SE→NW with arrowhead in upper-left corner
     *   X X X . .
     *   X X . . .
     *   X . X . .
     *   . X . . .
     *   . . X . .
     *   . . . X .
     *   . . . . X                                                  */
    {0x07, 0x0B, 0x15, 0x20, 0x40}, /* 0x87 ↖ */
};

void pk_font_putchar(uint16_t *fb, int fb_w, int fb_h,
                     int x, int y, char c,
                     uint16_t color, int scale)
{
    if (scale < 1) scale = 1;
    unsigned u = (unsigned char)c;
    /* 0x20..0x7F = printable ASCII, 0x80..0x87 = compass arrows. */
    if (u < 0x20 || u > 0x87) u = 0x20;

    const uint8_t *glyph = s_font[u - 0x20];

    for (int col = 0; col < PK_FONT_W; ++col) {
        uint8_t bits = glyph[col];
        for (int row = 0; row < PK_FONT_H; ++row) {
            if ((bits >> row) & 1) {
                int px = x + col * scale;
                int py = y + row * scale;
                for (int dy = 0; dy < scale; ++dy) {
                    int yy = py + dy;
                    if (yy < 0 || yy >= fb_h) continue;
                    uint16_t *line = fb + yy * fb_w;
                    for (int dx = 0; dx < scale; ++dx) {
                        int xx = px + dx;
                        if (xx < 0 || xx >= fb_w) continue;
                        line[xx] = color;
                    }
                }
            }
        }
    }
}

int pk_font_puts(uint16_t *fb, int fb_w, int fb_h,
                 int x, int y, const char *s,
                 uint16_t color, int scale)
{
    int x0 = x;
    const int cell_w = PK_FONT_CELL_W(scale);
    for (; s && *s; ++s) {
        /* Allow '~' as an ASCII-portable shorthand for the degree
         * glyph. The literal "\xb0" works too. */
        char c = *s;
        if ((unsigned char)c == 0xB0 || c == '~') c = PK_FONT_DEGREE;
        pk_font_putchar(fb, fb_w, fb_h, x, y, c, color, scale);
        x += cell_w;
    }
    return x - x0;
}

char pk_font_arrow_for_delta_deg(int delta_deg)
{
    /* Wrap delta into [0, 360). Use a while-loop rather than modulo so
     * the answer is correct regardless of how the input was clamped
     * upstream (e.g. heading subtraction can produce values in
     * [-360, +360]). */
    int d = delta_deg;
    while (d <    0) d += 360;
    while (d >= 360) d -= 360;

    /* Each compass arrow covers a 45°-wide sector centred on its
     * bearing: N → [-22°, +22°], NE → [+23°, +67°], etc. Add 22° to
     * fold the boundary so integer division by 45 yields the sector
     * index directly: idx 0 = N, 1 = NE, 2 = E, …, 7 = NW. */
    int idx = ((d + 22) / 45) % 8;
    return (char)(0x80 + idx);
}
